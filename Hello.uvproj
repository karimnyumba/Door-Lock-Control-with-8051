# Keil uVision project Hello.uvproj, settings and files
target Simulator (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: HELLO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: HELLO.C
  group Documentation
    ./: ABSTRACT.TXT
